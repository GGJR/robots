<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\blinkyFree.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\cell_tests\cell_tests.ewp</path>
  </project>
  <batchBuild/>
</workspace>


